# Keil uVision project LED.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LED +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\UCOS2\CONFIG;..\UCOS2\CORE;..\UCOS2\PORT;..\HARDWARE\finger;..\HARDWARE\USART2;..\HARDWARE\fatfs;..\HARDWARE\SD;..\BSP;..\UI\GUIinc;..\UI\TFT;..\UI\Touch;..\UI\uCGUIConfig;..\UI\uCOS-IIGUI_X;..\UCOS2\uC-CPU;..\HARDWARE\USERUI
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ../HARDWARE/SD/: sdio_sdcard.c
  group BSP
    ../BSP/: bsp.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/finger/: finger.c Fgstatus.c
    ../HARDWARE/USART2/: Usart2.c
    ../HARDWARE/USERUI/: MYUI.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_fsmc.c
  group FATFS
    ../HARDWARE/fatfs/: diskio.c ff.c
  group UCPU
    ../UCOS2/uC-CPU/: cpu_a.asm
  group UCOS2-CORE
    ../UCOS2/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOS2-PORT
    ../UCOS2/PORT/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group UCOS2-CONFIG
    ../UCOS2/CONFIG/: includes.h os_cfg.h
  group TFT
    ../UI/TFT/: fsmc_sram.c lcd.c lcd_api.c lcd_ucgui.c lcddrv.c
  group GUICONFIG
    ../UI/uCGUIConfig/: GUIConf.h GUITouchConf.h LCDConf.h
  group GUILIB
    ../UI/uCGUILib/: uCGUI_DEMO.lib
  group UCOSGUI
    ../UI/uCOS-IIGUI_X/: GUI_X_Touch.c GUI_X_uCOS.c
